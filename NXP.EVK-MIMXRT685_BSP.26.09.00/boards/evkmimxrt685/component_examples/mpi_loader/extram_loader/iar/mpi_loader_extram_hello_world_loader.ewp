# IAR project mpi_loader_extram_hello_world_loader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; FSL_SDK_DISABLE_DRIVER_RESET_CONTROL=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; MIMXRT685S_cm33_SERIES
  AARM.AUserIncludes: ..
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: extram_loader.bin
  ILINK.IlinkOutputFile: mpi_loader_extram_hello_world_loader.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; FSL_SDK_DISABLE_DRIVER_RESET_CONTROL=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES
  ICCARM.CCOptLevel: 3
  group source
    ../: extram_loader.c mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
