# Keil uVision project hello_world_swo_cm33.uvprojx, settings and files
target hello_world_swo_cm33 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: hello_world_swo_cm33.out
  AfterMake: fromelf.exe --output "$Lhello_world_swo.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, PRINTF_ADVANCED_ENABLE=0, PRINTF_FLOAT_ENABLE=0, SCANF_ADVANCED_ENABLE=0, SCANF_FLOAT_ENABLE=0, SERIAL_PORT_TYPE_SWO=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT685SFVKB_cm33, MIMXRT685S_cm33_SERIES
  c misc: -include ../mcux_config.h -include ../mcuxsdk_version.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT685SFVKB_cm33, MIMXRT685S_cm33_SERIES
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: hello_world_swo.c fsl_debug_console_conf.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target hello_world_swo_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: hello_world_swo_cm33.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: ..
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
target hello_world_swo_cm33 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: hello_world_swo_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, PRINTF_ADVANCED_ENABLE=0, PRINTF_FLOAT_ENABLE=0, SCANF_ADVANCED_ENABLE=0, SCANF_FLOAT_ENABLE=0, SERIAL_PORT_TYPE_SWO=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT685SFVKB_cm33, MIMXRT685S_cm33_SERIES
  c misc: as above
  c include: ..
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: as above
target hello_world_swo_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: hello_world_swo_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: ..
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
software components: Device:SDK drivers:evkmimxrt685_flash_config 2.0.0, CMSIS:CORE 6.1.0, Device:CMSIS:MIMXRT685S_header 1.0.0, Device:CMSIS:MIMXRT685S_system 1.0.0, Device:Startup 1.0.0, Device:SDK Drivers:clock 2.7.4, Device:SDK Drivers:dsp 2.1.1, Device:SDK Drivers:i2s_bridge 2.0.0, Device:SDK Drivers:inputmux_connections 2.0.0, Device:SDK Drivers:power 2.5.1, Device:SDK Drivers:reset 2.2.2, Device:SDK Drivers:cache_cache64 2.0.14, Device:SDK Drivers:common 2.6.6, Device:SDK Drivers:flexcomm 2.0.3, Device:SDK Drivers:usart 2.9.0, Device:SDK Drivers:flexspi 2.9.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:iopctl 2.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Utilities:str 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_swo 1.0.0
