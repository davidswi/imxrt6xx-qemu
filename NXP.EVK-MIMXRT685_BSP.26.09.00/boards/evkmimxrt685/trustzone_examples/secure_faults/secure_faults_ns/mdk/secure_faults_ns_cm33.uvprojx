# Keil uVision project secure_faults_ns_cm33.uvprojx, settings and files
target secure_faults_ns_cm33 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33")  TZ DSP
  output: secure_faults_ns_cm33.out
  AfterMake: fromelf.exe --output "$Lsecure_faults_ns.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT685SFVKB_cm33, MIMXRT685S_cm33_SERIES
  c misc: -include ../mcux_config.h -include ../mcuxsdk_version.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT685SFVKB_cm33, MIMXRT685S_cm33_SERIES
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram_ns.scf
  link misc: ../../secure_faults_s/mdk/debug/secure_faults_s_cm33_CMSE_lib.o --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: secure_faults_ns.c veneer_table.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group doc
    ../: examples_shared_readme.md
target secure_faults_ns_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33")  TZ DSP
  output: secure_faults_ns_cm33.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: ..
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash_ns.scf
  link misc: ../../secure_faults_s/mdk/flash_debug/secure_faults_s_cm33_CMSE_lib.o --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
target secure_faults_ns_cm33 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33")  TZ DSP
  output: secure_faults_ns_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT685SFVKB_cm33, MIMXRT685S_cm33_SERIES
  c misc: as above
  c include: ..
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram_ns.scf
  link misc: ../../secure_faults_s/mdk/release/secure_faults_s_cm33_CMSE_lib.o --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
target secure_faults_ns_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33")  TZ DSP
  output: secure_faults_ns_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: ..
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash_ns.scf
  link misc: ../../secure_faults_s/mdk/flash_release/secure_faults_s_cm33_CMSE_lib.o --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
software components: Device:SDK drivers:evkmimxrt685_flash_config 2.0.0, CMSIS:CORE 6.1.0, Device:CMSIS:MIMXRT685S_header 1.0.0, Device:CMSIS:MIMXRT685S_system 1.0.0, Device:Startup 1.0.0, Device:SDK Drivers:clock 2.7.4, Device:SDK Drivers:dsp 2.1.1, Device:SDK Drivers:i2s_bridge 2.0.0, Device:SDK Drivers:inputmux_connections 2.0.0, Device:SDK Drivers:power 2.5.1, Device:SDK Drivers:reset 2.2.2, Device:SDK Drivers:cache_cache64 2.0.14, Device:SDK Drivers:common 2.6.6, Device:SDK Drivers:flexcomm 2.0.3, Device:SDK Drivers:usart 2.9.0, Device:SDK Drivers:flexspi 2.9.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:iopctl 2.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, Device:SDK Utilities:str 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Drivers:usart_adapter 1.0.0
